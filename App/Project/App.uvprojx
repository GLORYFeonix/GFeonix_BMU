# Keil uVision project App.uvprojx, settings and files
target Debug (6210000::V6.21::ARMCLANG)
  device: GD32F303VG GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: App +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\Libraries\Firmware\CMSIS;..\..\Libraries\Firmware\CMSIS\GD\GD32F30x\Include;..\..\Libraries\Firmware\GD32F30x_standard_peripheral\Include;..\..\Libraries\RTT;..\..\Libraries\MultiButton;..\Application\Include;..\..\Libraries\BSP\Include;..\..\Libraries\DEV\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../Application/Source/: main.c systick.c gd32f30x_it.c sys_moniter.c key_check.c upper_comm.c pcs_comm.c bms_comm.c lcd_display.c buzzer_beep.c log.c
  group BSP
    ../../Libraries/BSP/Source/: bsp.c gpio.c i2c.c timer.c uart.c
  group DEV
    ../../Libraries/DEV/Source/: buzzer.c lcd.c crc.c
  group RTT
    ../../Libraries/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group MultiButton
    ../../Libraries/MultiButton/: multi_button.c
  group Peripherals
    ../../Libraries/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Device:Startup 2.2.0
